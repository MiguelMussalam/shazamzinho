#include "display.h"
#include <string.h>
#include "driver/i2c_master.h"
#include "esp_lcd_panel_io.h"
#include "esp_lcd_panel_ops.h"
#include "esp_lcd_panel_vendor.h"   // esp_lcd_new_panel_ssd1306 + esp_lcd_panel_ssd1306_config_t (esp_lcd core, IDF 5.4)
#include "esp_log.h"

// ---- Hardware (ver docs/fritzing/README.md) ----
#define OLED_SDA_GPIO      21
#define OLED_SCL_GPIO      22
#define OLED_I2C_HZ        400000      // 400 kHz
#define OLED_I2C_ADDR      0x3C        // alguns módulos usam 0x3D
#define OLED_WIDTH         128
#define OLED_HEIGHT        64
#define OLED_PAGES         (OLED_HEIGHT / 8)

static const char *TAG = "oled";

// Framebuffer: 1 bpp, organizado por página (igual à GDDRAM do SSD1306).
// byte = fb[page * largura + coluna]; bit (y & 7) = pixel vertical.
static uint8_t s_fb[OLED_WIDTH * OLED_PAGES];
static esp_lcd_panel_handle_t s_panel = NULL;
static bool s_ok = false;

// Fonte 5x7 ASCII 0x20..0x7E, colunas (bit0 = topo). Renderizamos 6 px de largura
// (5 da glifo + 1 de espaço). Tabela clássica de domínio público.
static const uint8_t FONT5X7[][5] = {
    {0x00,0x00,0x00,0x00,0x00}, // 0x20 (espaço)
    {0x00,0x00,0x5F,0x00,0x00}, // !
    {0x00,0x07,0x00,0x07,0x00}, // "
    {0x14,0x7F,0x14,0x7F,0x14}, // #
    {0x24,0x2A,0x7F,0x2A,0x12}, // $
    {0x23,0x13,0x08,0x64,0x62}, // %
    {0x36,0x49,0x55,0x22,0x50}, // &
    {0x00,0x05,0x03,0x00,0x00}, // '
    {0x00,0x1C,0x22,0x41,0x00}, // (
    {0x00,0x41,0x22,0x1C,0x00}, // )
    {0x14,0x08,0x3E,0x08,0x14}, // *
    {0x08,0x08,0x3E,0x08,0x08}, // +
    {0x00,0x50,0x30,0x00,0x00}, // ,
    {0x08,0x08,0x08,0x08,0x08}, // -
    {0x00,0x60,0x60,0x00,0x00}, // .
    {0x20,0x10,0x08,0x04,0x02}, // /
    {0x3E,0x51,0x49,0x45,0x3E}, // 0
    {0x00,0x42,0x7F,0x40,0x00}, // 1
    {0x42,0x61,0x51,0x49,0x46}, // 2
    {0x21,0x41,0x45,0x4B,0x31}, // 3
    {0x18,0x14,0x12,0x7F,0x10}, // 4
    {0x27,0x45,0x45,0x45,0x39}, // 5
    {0x3C,0x4A,0x49,0x49,0x30}, // 6
    {0x01,0x71,0x09,0x05,0x03}, // 7
    {0x36,0x49,0x49,0x49,0x36}, // 8
    {0x06,0x49,0x49,0x29,0x1E}, // 9
    {0x00,0x36,0x36,0x00,0x00}, // :
    {0x00,0x56,0x36,0x00,0x00}, // ;
    {0x08,0x14,0x22,0x41,0x00}, // <
    {0x14,0x14,0x14,0x14,0x14}, // =
    {0x00,0x41,0x22,0x14,0x08}, // >
    {0x02,0x01,0x51,0x09,0x06}, // ?
    {0x32,0x49,0x79,0x41,0x3E}, // @
    {0x7E,0x11,0x11,0x11,0x7E}, // A
    {0x7F,0x49,0x49,0x49,0x36}, // B
    {0x3E,0x41,0x41,0x41,0x22}, // C
    {0x7F,0x41,0x41,0x22,0x1C}, // D
    {0x7F,0x49,0x49,0x49,0x41}, // E
    {0x7F,0x09,0x09,0x09,0x01}, // F
    {0x3E,0x41,0x49,0x49,0x7A}, // G
    {0x7F,0x08,0x08,0x08,0x7F}, // H
    {0x00,0x41,0x7F,0x41,0x00}, // I
    {0x20,0x40,0x41,0x3F,0x01}, // J
    {0x7F,0x08,0x14,0x22,0x41}, // K
    {0x7F,0x40,0x40,0x40,0x40}, // L
    {0x7F,0x02,0x0C,0x02,0x7F}, // M
    {0x7F,0x04,0x08,0x10,0x7F}, // N
    {0x3E,0x41,0x41,0x41,0x3E}, // O
    {0x7F,0x09,0x09,0x09,0x06}, // P
    {0x3E,0x41,0x51,0x21,0x5E}, // Q
    {0x7F,0x09,0x19,0x29,0x46}, // R
    {0x46,0x49,0x49,0x49,0x31}, // S
    {0x01,0x01,0x7F,0x01,0x01}, // T
    {0x3F,0x40,0x40,0x40,0x3F}, // U
    {0x1F,0x20,0x40,0x20,0x1F}, // V
    {0x3F,0x40,0x38,0x40,0x3F}, // W
    {0x63,0x14,0x08,0x14,0x63}, // X
    {0x07,0x08,0x70,0x08,0x07}, // Y
    {0x61,0x51,0x49,0x45,0x43}, // Z
    {0x00,0x7F,0x41,0x41,0x00}, // [
    {0x02,0x04,0x08,0x10,0x20}, // backslash
    {0x00,0x41,0x41,0x7F,0x00}, // ]
    {0x04,0x02,0x01,0x02,0x04}, // ^
    {0x40,0x40,0x40,0x40,0x40}, // _
    {0x00,0x01,0x02,0x04,0x00}, // `
    {0x20,0x54,0x54,0x54,0x78}, // a
    {0x7F,0x48,0x44,0x44,0x38}, // b
    {0x38,0x44,0x44,0x44,0x20}, // c
    {0x38,0x44,0x44,0x48,0x7F}, // d
    {0x38,0x54,0x54,0x54,0x18}, // e
    {0x08,0x7E,0x09,0x01,0x02}, // f
    {0x0C,0x52,0x52,0x52,0x3E}, // g
    {0x7F,0x08,0x04,0x04,0x78}, // h
    {0x00,0x44,0x7D,0x40,0x00}, // i
    {0x20,0x40,0x44,0x3D,0x00}, // j
    {0x7F,0x10,0x28,0x44,0x00}, // k
    {0x00,0x41,0x7F,0x40,0x00}, // l
    {0x7C,0x04,0x18,0x04,0x78}, // m
    {0x7C,0x08,0x04,0x04,0x78}, // n
    {0x38,0x44,0x44,0x44,0x38}, // o
    {0x7C,0x14,0x14,0x14,0x08}, // p
    {0x08,0x14,0x14,0x18,0x7C}, // q
    {0x7C,0x08,0x04,0x04,0x08}, // r
    {0x48,0x54,0x54,0x54,0x20}, // s
    {0x04,0x3F,0x44,0x40,0x20}, // t
    {0x3C,0x40,0x40,0x20,0x7C}, // u
    {0x1C,0x20,0x40,0x20,0x1C}, // v
    {0x3C,0x40,0x30,0x40,0x3C}, // w
    {0x44,0x28,0x10,0x28,0x44}, // x
    {0x0C,0x50,0x50,0x50,0x3C}, // y
    {0x44,0x64,0x54,0x4C,0x44}, // z
    {0x00,0x08,0x36,0x41,0x00}, // {
    {0x00,0x00,0x7F,0x00,0x00}, // |
    {0x00,0x41,0x36,0x08,0x00}, // }
    {0x08,0x04,0x08,0x10,0x08}, // ~
};

// Sem OLED o firmware precisa seguir funcionando (serial + rede). Por isso nenhuma
// falha aqui aborta: o erro é logado, s_ok fica false e as funções de desenho viram no-op.
static bool s_tentado = false;
static esp_err_t s_resultado = ESP_FAIL;

esp_err_t display_init(void)
{
    // idempotente: chamado no app_main e na task. Só tenta uma vez — repetir depois de
    // uma falha recriaria o barramento I2C, que já ficou alocado.
    if (s_tentado) return s_resultado;
    s_tentado = true;

    // 1) Barramento I2C mestre (nova API i2c_master do ESP-IDF 5.x).
    i2c_master_bus_handle_t bus = NULL;
    i2c_master_bus_config_t bus_cfg = {
        .clk_source = I2C_CLK_SRC_DEFAULT,
        .i2c_port = I2C_NUM_0,
        .scl_io_num = OLED_SCL_GPIO,
        .sda_io_num = OLED_SDA_GPIO,
        .glitch_ignore_cnt = 7,
        .flags.enable_internal_pullup = true,
    };
    esp_err_t err = i2c_new_master_bus(&bus_cfg, &bus);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "i2c_new_master_bus falhou: %s", esp_err_to_name(err));
        return s_resultado = err;
    }

    // Sonda o endereço antes de configurar o painel: dá um diagnóstico claro quando o
    // OLED não está ligado (ou está em 0x3D) em vez de uma cascata de erros de NACK.
    err = i2c_master_probe(bus, OLED_I2C_ADDR, 50);
    if (err != ESP_OK) {
        ESP_LOGW(TAG, "OLED nao respondeu em 0x%02X (%s): seguindo sem display. "
                 "Confira SDA=GPIO%d, SCL=GPIO%d, VCC e GND.",
                 OLED_I2C_ADDR, esp_err_to_name(err), OLED_SDA_GPIO, OLED_SCL_GPIO);
        for (uint16_t addr = 0x08; addr < 0x78; addr++) {
            if (i2c_master_probe(bus, addr, 20) == ESP_OK) {
                ESP_LOGW(TAG, "  dispositivo I2C encontrado em 0x%02X", addr);
            }
        }
        i2c_del_master_bus(bus);
        return s_resultado = err;
    }

    // 2) Camada panel_io I2C para o SSD1306.
    esp_lcd_panel_io_handle_t io = NULL;
    esp_lcd_panel_io_i2c_config_t io_cfg = {
        .dev_addr = OLED_I2C_ADDR,
        .scl_speed_hz = OLED_I2C_HZ,
        .control_phase_bytes = 1,
        .dc_bit_offset = 6,
        .lcd_cmd_bits = 8,
        .lcd_param_bits = 8,
    };
    err = esp_lcd_new_panel_io_i2c(bus, &io_cfg, &io);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "panel_io_i2c falhou: %s", esp_err_to_name(err));
        return s_resultado = err;
    }

    // 3) Painel SSD1306 (componente gerenciado espressif/esp_lcd_panel_ssd1306).
    esp_lcd_panel_ssd1306_config_t ssd_cfg = { .height = OLED_HEIGHT };
    esp_lcd_panel_dev_config_t panel_cfg = {
        .bits_per_pixel = 1,
        .reset_gpio_num = -1,        // módulo sem pino de reset
        .vendor_config = &ssd_cfg,
    };
    err = esp_lcd_new_panel_ssd1306(io, &panel_cfg, &s_panel);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "new_panel_ssd1306 falhou: %s", esp_err_to_name(err));
        return s_resultado = err;
    }

    if ((err = esp_lcd_panel_reset(s_panel)) != ESP_OK ||
        (err = esp_lcd_panel_init(s_panel)) != ESP_OK ||
        (err = esp_lcd_panel_disp_on_off(s_panel, true)) != ESP_OK) {
        ESP_LOGE(TAG, "inicializacao do SSD1306 falhou: %s — seguindo sem display", esp_err_to_name(err));
        return s_resultado = err;
    }

    s_ok = true;
    s_resultado = ESP_OK;
    display_clear();
    display_flush();
    ESP_LOGI(TAG, "OLED SSD1306 pronto (%dx%d, addr 0x%02X)", OLED_WIDTH, OLED_HEIGHT, OLED_I2C_ADDR);
    return ESP_OK;
}

void display_clear(void)
{
    memset(s_fb, 0, sizeof(s_fb));
}

void display_flush(void)
{
    if (!s_ok) return;
    // Empurra o frame inteiro. O painel SSD1306 do esp_lcd espera o buffer em
    // formato de página (o mesmo layout de s_fb).
    esp_lcd_panel_draw_bitmap(s_panel, 0, 0, OLED_WIDTH, OLED_HEIGHT, s_fb);
}

// Escreve 1 coluna de 8 pixels no framebuffer.
static void put_col(int x, int page, uint8_t bits)
{
    if (x < 0 || x >= OLED_WIDTH || page < 0 || page >= OLED_PAGES) return;
    s_fb[page * OLED_WIDTH + x] = bits;
}

void display_text(int x, int page, const char *s)
{
    for (; *s; s++) {
        unsigned char c = (unsigned char) *s;
        if (c < 0x20 || c > 0x7E) c = 0x20;
        const uint8_t *g = FONT5X7[c - 0x20];
        for (int col = 0; col < 5; col++) put_col(x + col, page, g[col]);
        put_col(x + 5, page, 0x00);   // espaço entre caracteres
        x += 6;
        if (x >= OLED_WIDTH) break;
    }
}

void display_vu(int page, int level_0_100)
{
    if (page < 0 || page >= OLED_PAGES) return;
    if (level_0_100 < 0) level_0_100 = 0;
    if (level_0_100 > 100) level_0_100 = 100;
    int filled = (OLED_WIDTH * level_0_100) / 100;
    // Moldura: bordas superior/inferior (bits 0 e 7) em toda a largura;
    // preenche as colunas até 'filled'.
    for (int x = 0; x < OLED_WIDTH; x++) {
        uint8_t bits = 0x81;              // topo + base da barra
        if (x < filled) bits = 0xFF;      // coluna cheia
        if (x == 0 || x == OLED_WIDTH - 1) bits = 0xFF; // laterais da moldura
        put_col(x, page, bits);
    }
}
